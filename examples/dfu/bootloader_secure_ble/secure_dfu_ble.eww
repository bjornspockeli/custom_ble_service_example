<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\iar\secure_dfu_ble_s132_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\iar\secure_dfu_ble_s140_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040_debug\iar\secure_dfu_ble_s132_pca10040_debug.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056_debug\iar\secure_dfu_ble_s140_pca10056_debug.ewp</path>
  </project>  <batchBuild/>
</workspace>