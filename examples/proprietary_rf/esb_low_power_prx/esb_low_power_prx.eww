<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\blank\iar\esb_low_power_prx_pca10040.ewp</path>
  </project>  <batchBuild/>
</workspace>