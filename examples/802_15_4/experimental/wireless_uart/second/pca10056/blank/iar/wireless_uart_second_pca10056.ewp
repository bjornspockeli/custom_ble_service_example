# IAR project wireless_uart_second_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; NRF52840_XXAA
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\..\components\experimental_802_15_4; ..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\HAL; ..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\HAL\nrf52_soc; ..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\MAC; ..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\PHY; ..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\RAL; ..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\RAL\nrf52_soc; ..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\SecAL; ..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\SysAL; ..\..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..; ..\..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; NRF52840_XXAA
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wireless_uart_second_pca10056.hex
  ILINK.IlinkOutputFile: wireless_uart_second_pca10056.out
  ILINK.IlinkIcfFile: wireless_uart_second_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_802_15_4
    ../../../../../../../../components/experimental_802_15_4/: 802_15_4_lib_iar.a
    ../../../../../../../../components/experimental_802_15_4/src/: rng_entity.c sec_aes_entity.c
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../components/drivers_nrf/hal/: nrf_ecb.c
    ../../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group Application
    ../../../../: assert.c fsm.c main.c security.c uart.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Device
    ../../../../../../../../components/toolchain/iar/: iar_startup_nrf52840.s
    ../../../../../../../../components/toolchain/: system_nrf52840.c
