<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\secure_dfu_serial_s132_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\secure_dfu_serial_s140_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040_debug\s132\iar\secure_dfu_serial_s132_pca10040_debug.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056_debug\s140\iar\secure_dfu_serial_s140_pca10056_debug.ewp</path>
  </project>  <batchBuild/>
</workspace>