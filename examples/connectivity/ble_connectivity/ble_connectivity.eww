<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_spi\iar\ble_connectivity_s132_spi_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_hci\iar\ble_connectivity_s132_hci_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_uart\iar\ble_connectivity_s132_uart_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_spi_5W\iar\ble_connectivity_s132_spi_5W_pca10040.ewp</path>
  </project>  <batchBuild/>
</workspace>