# IAR project twi_master_with_twis_slave_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; DEBUG_NRF; NRF52840_XXAA; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\twi_master; ..\..\..\..\..\..\components\drivers_nrf\twis_slave; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\experimental_cli; ..\..\..\..\..\..\components\libraries\experimental_cli\uart; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_ringbuf; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twi_master_with_twis_slave_pca10056.hex
  ILINK.IlinkOutputFile: twi_master_with_twis_slave_pca10056.out
  ILINK.IlinkIcfFile: twi_master_with_twis_slave_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../components/libraries/experimental_cli/: nrf_cli.c
    ../../../../../../components/libraries/experimental_cli/uart/: nrf_cli_uart.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/experimental_ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/twis_slave/: nrf_drv_twis.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Application
    ../../../: eeprom_simulator.c main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52840.s
    ../../../../../../components/toolchain/: system_nrf52840.c
