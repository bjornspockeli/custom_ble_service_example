# Keil uVision project chacha_poly_pca10056.uvprojx, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CHACHA_INTEGTEST CONFIG_GPIO_AS_PINRESET DEBUG DEBUG_NRF DX_CC_TEE NRF52840_XXAA NRF_LOG_BACKEND_RTT_OUTPUT_BUFFER_SIZE=2048 NRF_LOG_ENABLED=1 NRF_LOG_USES_RTT=1 NRF_SDK_PRESENT SEGGER_RTT_BLOCKING __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\..\external\nrf_cc310\common;..\..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DBSP_DEFINES_ONLY,-DCHACHA_INTEGTEST,-DCONFIG_GPIO_AS_PINRESET,-DDEBUG,-DDEBUG_NRF,-DDX_CC_TEE,-DNRF52840_XXAA,-DNRF_LOG_BACKEND_RTT_OUTPUT_BUFFER_SIZE=2048,-DNRF_LOG_ENABLED=1,-DNRF_LOG_USES_RTT=1,-DNRF_SDK_PRESENT,-DSEGGER_RTT_BLOCKING,-D__STACK_SIZE=2048
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group None
    ../../../../../../../external/nrf_cc310/common/: integration_test_plat_utils.c
  group Application
    ../../../: integration_test_cc_chacha_poly_vectors.c main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../../components/libraries/util/: app_util_platform.c nrf_assert.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nrf_cc310
    ../../../../../../../external/nrf_cc310/lib/: cc310_keil_0.9.0.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 8.14.1
