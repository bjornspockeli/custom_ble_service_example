<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\iar\secure_dfu_usb_s140_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056_debug\iar\secure_dfu_usb_s140_pca10056_debug.ewp</path>
  </project>  <batchBuild/>
</workspace>