# IAR project nfc_writable_ndef_msg_pca10056_s140.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; NRF52840_XXAA; NRF_SD_BLE_API_VERSION=5; S140; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\ble\ble_racp; ..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_ans_c; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_gls; ..\..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_hts; ..\..\..\..\..\..\components\ble\ble_services\ble_ias; ..\..\..\..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lls; ..\..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_tps; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\..\..\components\ble\peer_manager; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\comp; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\i2s; ..\..\..\..\..\..\components\drivers_nrf\lpcomp; ..\..\..\..\..\..\components\drivers_nrf\pdm; ..\..\..\..\..\..\components\drivers_nrf\power; ..\..\..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\..\..\components\drivers_nrf\pwm; ..\..\..\..\..\..\components\drivers_nrf\qdec; ..\..\..\..\..\..\components\drivers_nrf\rng; ..\..\..\..\..\..\components\drivers_nrf\rtc; ..\..\..\..\..\..\components\drivers_nrf\saadc; ..\..\..\..\..\..\components\drivers_nrf\spi_master; ..\..\..\..\..\..\components\drivers_nrf\spi_slave; ..\..\..\..\..\..\components\drivers_nrf\swi; ..\..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\..\components\drivers_nrf\twi_master; ..\..\..\..\..\..\components\drivers_nrf\twis_slave; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\drivers_nrf\usbd; ..\..\..\..\..\..\components\drivers_nrf\wdt; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\components\libraries\csense; ..\..\..\..\..\..\components\libraries\csense_drv; ..\..\..\..\..\..\components\libraries\ecc; ..\..\..\..\..\..\components\libraries\experimental_cli; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\fds; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\hardfault\nrf52; ..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\twi; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\components\libraries\usbd\class\audio; ..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\components\libraries\usbd\class\hid; ..\..\..\..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\..\..\..\components\libraries\usbd\class\msc; ..\..\..\..\..\..\components\libraries\usbd\config; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\..\components\nfc\ndef\uri; ..\..\..\..\..\..\components\nfc\t4t_lib; ..\..\..\..\..\..\components\nfc\t4t_lib\hal_t4t; ..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\..\..\components\softdevice\s140\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nfc_writable_ndef_msg_pca10056_s140.hex
  ILINK.IlinkOutputFile: nfc_writable_ndef_msg_pca10056_s140.out
  ILINK.IlinkIcfFile: nfc_writable_ndef_msg_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
  group Application
    ../../../: main.c ndef_file_m.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_srv_common.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52840.s
    ../../../../../../components/toolchain/: system_nrf52840.c
  group nRF_NFC
    ../../../../../../components/nfc/t4t_lib/hal_t4t/: hal_nfc_t4t.c
    ../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../components/nfc/t4t_lib/: nfc_t4t_lib_iar.a
    ../../../../../../components/nfc/ndef/uri/: nfc_uri_msg.c nfc_uri_rec.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_soc.c
